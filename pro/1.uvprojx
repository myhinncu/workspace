# Keil uVision project 1.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\AC5)
  device: GD32F450IG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F450,USE_USB_FS,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\GD\GD32F4xx\Include;..\CMSIS;..\GD32F4xx_standard_peripheral\Include;..\Utilities;..\Application;..\GD32F4xx_EVAL;..\GD32F4xx_EVAL\controler_mcu_protocol;..\freeRTOS\include;..\freeRTOS\portable\MemMang;..\freeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../Application/: gd32f4xx_libopt.h key.c key.h led.c led.h main.c systick.c systick.h
  group CMSIS
    ../CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group GD32F4xx_standard_peripheral
    ../GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group GD32F4xx_EVAL
    ../GD32F4xx_EVAL/: gd32f450i_eval.c usart_urbantoo.c usart_urbantoo.h ubt_motor.c ubt_motor.h
    ../GD32F4xx_EVAL/controler_mcu_protocol/: bluetooth_protocol.c copy.c gd32f4xx_it.c initialization.c
  group startup
    ../startup/: startup_gd32f450_470.s
  group FreeRTOS-src
    ../freeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS-portable
    ../freeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../freeRTOS/portable/MemMang/: heap_4.c
